## drivers/misc/mediatek/connectivity/Kconfig
```kconfig
config MTK_COMBO_AOSP_TETHERING_SUPPORT
	bool "Multiplex wlan0 for both AP and STA"
	default n
```
